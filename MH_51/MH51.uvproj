# Keil uVision project MH51.uvproj, settings and files
target MH51Pro (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: MH51
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\app;.\src\include;.\src\driver
  group app
    ./: main.c
  group startup
    ./: STARTUP.A51
